*-- PDN network generated by pdngen
.param VDDMIN=0.95

*-- decap parameter
.include "t1.sp.decap"

*-- pg network
.include "t1.sp.rc"

*-- row=0 cellno=5
rvdd_0_0 nvdd_0_0 nvdd_0_1 {rvdd_0_0_val}
rvss_0_0 nvss_0_0 nvss_0_1 {rvss_0_0_val}
cvds_0_0 nvdd_0_0 nvss_0_0 {cvds_0_0_val}
rvdd_0_1 nvdd_0_1 nvdd_0_2 {rvdd_0_1_val}
rvss_0_1 nvss_0_1 nvss_0_2 {rvss_0_1_val}
cvds_0_1 nvdd_0_1 nvss_0_1 {cvds_0_1_val}
rvdd_0_2 nvdd_0_2 nvdd_0_3 {rvdd_0_2_val}
rvss_0_2 nvss_0_2 nvss_0_3 {rvss_0_2_val}
cvds_0_2 nvdd_0_2 nvss_0_2 {cvds_0_2_val}
rvdd_0_3 nvdd_0_3 nvdd_0_4 {rvdd_0_3_val}
rvss_0_3 nvss_0_3 nvss_0_4 {rvss_0_3_val}
cvds_0_3 nvdd_0_3 nvss_0_3 {cvds_0_3_val}
rvdd_0_4 nvdd_0_4 nvdd_0_5 {rvdd_0_4_val}
rvss_0_4 nvss_0_4 nvss_0_5 {rvss_0_4_val}
cvds_0_4 nvdd_0_4 nvss_0_4 {cvds_0_4_val}
rvdd_0_l nvdd nvdd_0_0 0.01
rvdd_0_r nvdd nvdd_0_5 0.01
rvss_0_l nvss nvss_0_0 0.01
rvss_0_r nvss nvss_0_5 0.01
*iload_0_0 nvdd_0_0 nvss_0_0 pwl(0 0.0 6.031e-09 0.0  6.083e-09 3.7e-01  6.135e-09 0.0)
*iload_0_1 nvdd_0_1 nvss_0_1 pwl(0 0.0 8.618e-09 0.0  8.682e-09 9.2e-01  8.746e-09 0.0)
*iload_0_2 nvdd_0_2 nvss_0_2 pwl(0 0.0 6.738e-09 0.0  6.799e-09 1.5e-01  6.861e-09 0.0)
*iload_0_3 nvdd_0_3 nvss_0_3 pwl(0 0.0 1.130e-09 0.0  1.145e-09 2.5e-01  1.160e-09 0.0)
*iload_0_4 nvdd_0_4 nvss_0_4 pwl(0 0.0 7.433e-09 0.0  7.474e-09 1.7e-01  7.515e-09 0.0)
iload_0_0 nvdd_0_0 nvss_0_0 pwl(0 0.0 6.031e-09 0.0  6.083e-09 2.7e-01  6.135e-09 0.0)
iload_0_1 nvdd_0_1 nvss_0_1 pwl(0 0.0 8.618e-09 0.0  8.682e-09 2.2e-01  8.746e-09 0.0)
iload_0_2 nvdd_0_2 nvss_0_2 pwl(0 0.0 6.738e-09 0.0  6.799e-09 5.5e-01  6.861e-09 0.0)
iload_0_3 nvdd_0_3 nvss_0_3 pwl(0 0.0 1.130e-09 0.0  1.145e-09 1.5e-01  1.160e-09 0.0)
iload_0_4 nvdd_0_4 nvss_0_4 pwl(0 0.0 7.433e-09 0.0  7.474e-09 8.7e-01  7.515e-09 0.0)

*-- decap for row 0
c_decap_0_0 nvdd_0_0 nvss_0_0 {cap_0_0_val}
bz_0_0 0 z_0_0 i={max((VDDMIN-v(nvdd_0_0,nvss_0_0)), 0.0)}
cz_0_0 0 z_0_0 1.0
rz_0_0 0 z_0_0 1.0e12
c_decap_0_1 nvdd_0_1 nvss_0_1 {cap_0_1_val}
bz_0_1 0 z_0_1 i={max((VDDMIN-v(nvdd_0_1,nvss_0_1)), 0.0)}
cz_0_1 0 z_0_1 1.0
rz_0_1 0 z_0_1 1.0e12
c_decap_0_2 nvdd_0_2 nvss_0_2 {cap_0_2_val}
bz_0_2 0 z_0_2 i={max((VDDMIN-v(nvdd_0_2,nvss_0_2)), 0.0)}
cz_0_2 0 z_0_2 1.0
rz_0_2 0 z_0_2 1.0e12
c_decap_0_3 nvdd_0_3 nvss_0_3 {cap_0_3_val}
bz_0_3 0 z_0_3 i={max((VDDMIN-v(nvdd_0_3,nvss_0_3)), 0.0)}
cz_0_3 0 z_0_3 1.0
rz_0_3 0 z_0_3 1.0e12
c_decap_0_4 nvdd_0_4 nvss_0_4 {cap_0_4_val}
bz_0_4 0 z_0_4 i={max((VDDMIN-v(nvdd_0_4,nvss_0_4)), 0.0)}
cz_0_4 0 z_0_4 1.0
rz_0_4 0 z_0_4 1.0e12

*-- z[] for row 0
bz_0 z_0 0 v={
+v(z_0_0)+
+v(z_0_1)+
+v(z_0_2)+
+v(z_0_3)+
+v(z_0_4)
+}
rbz_0 z_0 0 1e12

*-- total Z for all rows
bz_total z_total 0 v={
+v(z_0)}
rbz_total z_total 0 1e12

*-- power source
vdd nvdd 0 1
vss nvss 0 0.0

*-- analysis
.tran 1p 1e-08

.save all
*-- print options
.options filetype=ascii interp
.end
